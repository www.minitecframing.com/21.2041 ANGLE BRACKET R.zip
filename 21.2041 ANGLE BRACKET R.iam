# Autodesk Inventor assembly: 21.2041 ANGLE BRACKET R
## iProperties
Created: 2007-01
Part Number: 21.2041 ANGLE BRACKET R
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
